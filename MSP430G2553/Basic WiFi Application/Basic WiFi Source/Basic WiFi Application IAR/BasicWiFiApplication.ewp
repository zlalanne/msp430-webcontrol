# IAR project BasicWiFiApplication.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CC3000_UNENCRYPTED_SMART_CONFIG; CC3000_TINY_DRIVER
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\CC3000 Spi; ..\Source\inc; ..\Source\HyperTerminal Driver
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Source/BasicWiFi Application/: application_version.h basic_wifi_application.c board.c board.h
  group Libraries
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43 HyperTerminalDriver.r43
