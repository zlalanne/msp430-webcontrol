<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BasicWiFiApplication.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC3000 Host Driver.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC3000_Spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\HyperTerminalDriver.ewp</path>
  </project>
  <batchBuild/>
</workspace>


