# IAR project CC3000 Host Driver.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CC3000_UNENCRYPTED_SMART_CONFIG; CC3000_TINY_DRIVER
  ICC430.CCDiagSuppress: Pa039
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\CC3000 Spi; ..\Source\inc; ..\Source\BasicWiFi Application
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../Source/CC3000HostDriver/: cc3000_common.c cc3000_common.h evnt_handler.c evnt_handler.h hci.c hci.h host_driver_version.h netapp.c netapp.h nvmem.c nvmem.h socket.c socket.h wlan.c wlan.h
